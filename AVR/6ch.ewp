# IAR project 6ch.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-0t-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.IccLang: 1
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x80
  General.SCRStackSize: 64
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.GenDeviceSelectMenu: m168pa ATmega168PA
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm168pa.xcl
  XLINK.XExtraOptions: -Ointel-standard,(CODE)=$EXE_DIR$\6ch.hex; -Ointel-standard,(XDATA)=$EXE_DIR$\6ch.e2p
  group (top)
    ./: main.cpp
  group headers
    ./: core.h defs.h hmi.h I2C.H PCF8583.H shell.h timers.h uart.h
  group sources
    ./: core.c I2C.C PCF8583.C shell.c timers.c uart.c
